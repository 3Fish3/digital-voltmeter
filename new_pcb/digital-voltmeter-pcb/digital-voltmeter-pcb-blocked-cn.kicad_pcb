# Repository 3Fish3/digital-voltmeter

File README.md:

# STM32＋ADC0832双通道数字电压表

课程设计项目：两路共地0～5V直流采集，使用STM32与ADC0832，配套显示、串口及平均降噪实验。文档按目标、进度和现行设计三个用途维护。

## 当前版本

当前为**V2.3受控原理图草案**，工程位于`hardware/v2.3/`。64个位号中64个位号已全部分配封装；采购BOM和PCB尚未定稿，保护、精度及实物验证仍待完成，当前不投板。最新状态与检查证据统一记录在进度文档。

## 从这里开始

1. [项目最初目标](docs/project-goals.md)：课程目的、原始功能和验收来源。
2. [当前进度与问题](docs/progress.md)：完成情况、问题及关闭条件、验证记录和下一步。
3. [最新设计报告](docs/design-report.md)：当前电路、接口、参数、预算与完整网络表。

维护方式见[文档导航](docs/README.md)。每次设计更新后完整重写同一份设计报告，变更过程与问题记入进度。

## 目录

- `docs/`：三份主文档、[逐引脚CSV](docs/pin-connections.csv)、旧BOM与阶段交接。
- `hardware/v2.3/`：KiCad草案、局部图符/项目封装库、连接蓝图和[原理图PDF](hardware/v2.3/review/voltmeter-v2.3-draft.pdf)。
- `references/datasheets/`：本地数据手册和应用说明。
- `scripts/`、`tests/`：条件预算、网表核对工具及回归测试。
- `pictures/`：旧版板卡渲染、理想前端仿真图和Gerber包；与V2.3工程区分使用。
- `.tmp/`：本地计算、验证数据和文档整理快照，由`.gitignore`排除。

## 工具测试与本地验证数据

在仓库根目录可运行独立预算测试：

```bash
PYTHONDONTWRITEBYTECODE=1 python3 -m unittest discover -s tests -p test_reference_sampling_budget.py -v
```

本次开发分支在已备好`.tmp/v2.3-validation/`网表夹具的环境中通过21项测试，包括预算、网表和新增的封装/焊盘检查。完整测试依赖`defusedxml`及该目录中的KiCad导出XML、独立元件清单与标签清单；前置条件、命令和证据见[进度验证记录](docs/progress.md#4-验证记录与复现)。

真实封装实施记录、PR #1检查及原始ERC/网表/焊盘/BOM证据见[封装开发记录](docs/reviews/2026-10-23-v2.3-footprint-development/README.md)。

## KiCad design new_pcb/digital-voltmeter-pcb/digital-voltmeter-pcb-blocked-cn.kicad_pcb

Parts:
C1, C4: 1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2, C8: 10uF; CP_Radial_D5.0mm_P2.00mm
C3, C5, C6: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C7: 100uF; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal_ClearSilk
FB1: Ferrite_Bead; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole_3.2mm_M3
J1: BluePill_STM32F103C8T6
J4, J5: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J6, J7, J8: Conn_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
R1, R2, R7, R12: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 10M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R13, R14: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: ADC0832; DIP-8_W7.62mm
U2: 74AHCT125; DIP-14_W7.62mm
U3: MCP6002-xP; DIP-8_W7.62mm

Connections:
+3.3V: J1.2 (+3V3), J4.1, R9.1, R10.1, R12.2
+5V: C5.1, C6.1, C7.1, C8.1, D1.1 (K), D4.1 (K), FB1.1, J1.6 (+5V), J6.1, U2.14 (VCC), U3.8 (V+)
/ADC_5V: C2.1, C3.2, FB1.2, U1.8 (VCC)
/ADC_CH1: C1.1, R5.1, U1.2 (ANALOG0)
/ADC_CH2: C4.1, R6.1, U1.3 (ANALOG1)
/ADC_CLK_3V3: J1.38 (PB13), R13.1, U2.5
/ADC_CLK_5V: U1.7 (CLK), U2.6
/ADC_CS_3V3: J1.40 (PB12), R12.1, U2.2
/ADC_CS_5V: U1.1 (CS), U2.3
/ADC_DI_3V3: J1.34 (PB15), R14.2, U2.9
/ADC_DI_5V: U1.5 (DIN), U2.8
/ADC_DO_3V3: J1.36 (PB14), R7.2, R8.2
/ADC_DO_5V: R11.2, U1.6 (DOUT), U2.12
/ADC_DO_BUF_5V: R7.1, U2.11
/BUF_CH1: R5.2, U3.1, U3.2 (-)
/BUF_CH2: R6.2, U3.6 (-), U3.7
/I2C_SCL: J1.14 (PB6), J4.3, R9.2
/I2C_SDA: J1.12 (PB7), J4.4, R10.2
/UART_RX: J1.28 (PA10), J5.3
/UART_TX: J1.30 (PA9), J5.4
/VIN_CH1: D1.2 (A), D2.1 (K), R1.2, R3.1, U3.3 (+)
/VIN_CH2: D3.1 (K), D4.2 (A), R2.2, R4.1, U3.5 (+)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, D2.2 (A), D3.2 (A), J1.4 (GND), J4.2, J5.2, J6.2, J7.2, J8.2, R3.2, R4.2, R8.1, R11.1, R13.2, R14.1, U1.4 (GND), U2.1, U2.4, U2.7 (GND), U2.10, U2.13, U3.4 (V-)
unnamed: J7.1, R1.1
unnamed: J8.1, R2.1

Notes on the sheet:
① 电源输入与 ADC 电源滤波
⑦ ADC0832 双通道采样
安全提示：USB 供电与外部 +5V 不得同时接入
跨模块信号使用同名网络标签连接；模块内保留原电气连接
③ OLED 显示接口
④ UART 通信接口
② Blue Pill 主控模块
⑤ 通道 1 模拟前端
⑥ 通道 2 模拟前端
⑧ 74AHCT125 数字缓冲与电平转换

Board: 2 copper layers, 100.0 x 80.0 mm, 40 parts (0 on the bottom side), 25 nets.

File docs/component_footprint_checklist.md:

# Component - Footprint Checklist

| Component | Value | Footprint Assigned | Status |
|-----------|-------|--------------------|--------|
| U1        | ADC0832 | `Package_DIP:DIP-8_W7.62mm` | Validated (DIP-8 required) |
| U2        | 74AHCT125 | `Package_DIP:DIP-14_W7.62mm` | Validated (DIP-14 required) |
| U3        | MCP6002-xP | `Package_DIP:DIP-8_W7.62mm` | Validated (DIP-8 required) |
| FB1       | Ferrite_Bead | `Resistor_THT:R_Axial_DIN0207...` | Validated (Need part verification) |
| J4, J5    | Conn_01x04 | `Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical` | Validated |
| J6, J7, J8| Conn_01x02 | `TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal` | Validated |
| C1, C4, C5| 1uF, 1uF, 100nF | `Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm` | Validated |
| C6        | 100nF | `Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm` | Validated (Assigned by agent) |
| C2, C8    | 10uF | `Capacitor_THT:CP_Radial_D5.0mm_P2.00mm` | Validated (Polarized) |
| C7        | 100uF | `Capacitor_THT:CP_Radial_D6.3mm_P2.50mm` | Validated (Polarized) |
| R1..R14   | Resistors | `Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal` | Validated (All axial THT) |
| D1..D4    | 1N4148 | `Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal` | Validated |
| J1        | Blue Pill | **[None]** | **BLOCKED**: Withheld per instructions pending physical measurement. |

*Note: All components matching handoff requirements now have appropriate through-hole (THT) footprints except J1, which awaits physical measurement verification to prevent unverified physical mismatches.*
